File: KICAD PCBs/MainPCB_HS/EnvKB_HS.kicad_pcb (KiCad board)
At the start: 2 copper layers, 347 x 156.3 mm, 228 parts

Commit message: updated mount holes to be correct
Parts:
- renumbered H4 to H5
